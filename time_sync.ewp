# IAR project time_sync.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_STDPERIPH_DRIVER; STM32F40_41xxx; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\libs\stdlib\inc; src\libs\cmsis\Include; src\libs\cmsis\Device\ST\STM32F4xx\Include; src\app; src\bsp; src\rtos\freertos\config; src\rtos\freertos\include; src\rtos\freertos\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: src\rtos\freertos\config
  OBJCOPY.OOCOutputFile: time_sync.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    src/app/: main.c stm32f4xx_it.c
  group bsp
    src/bsp/: bsp_gpio.c bsp_timer.c bsp_uart.c
  group libs/cmsis/startup
    src/libs/cmsis/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    src/libs/cmsis/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group libs/stdlib
    src/libs/stdlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group rtos
    src/rtos/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    src/rtos/freertos/config/: FreeRTOSConfig.h
    src/rtos/freertos/portable/MemMang/: heap_4.c
    src/rtos/freertos/portable/IAR/ARM_CM4F/: port.c portasm.s
